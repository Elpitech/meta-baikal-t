require linux-baikal.inc

# Override any kernel-version specific settings here
