require u-boot-baikal-common.inc
require recipes-bsp/u-boot/u-boot-tools.inc
